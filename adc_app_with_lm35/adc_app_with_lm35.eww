<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\adc_app_with_lm35.ewp</path>
    </project>
    <batchBuild />
</workspace>
